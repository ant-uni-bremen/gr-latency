options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: tag_timestamp_demo
    output_language: python
    title: Tag Timestamp demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: length_tag_name
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: '113'
    minsize: '113'
  states: {}
- name: latency_pdu_time_stamper_0
  id: latency_pdu_time_stamper
  parameters:
    key_string: '"time"'
    name: '"pdu timestamp debug"'
  states: {}
- name: latency_tag_timestamp_debug_0
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: formatter
    num_inputs: '1'
    type: byte
    vlen: '1'
  states: {}
- name: latency_tag_timestamp_debug_0_0
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: float
    num_inputs: '1'
    type: float
    vlen: '1'
  states: {}

connections:
- [blocks_char_to_float_0, '0', latency_tag_timestamp_debug_0_0, '0']
- [blocks_message_strobe_0_0, strobe, blocks_random_pdu_0, generate]
- [blocks_pdu_to_tagged_stream_0_1, '0', blocks_char_to_float_0, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', latency_tag_timestamp_debug_0, '0']
- [blocks_random_pdu_0, pdus, latency_pdu_time_stamper_0, PDUin]
- [latency_pdu_time_stamper_0, PDUout, blocks_pdu_to_tagged_stream_0_1, pdus]

metadata:
  file_format: 1
