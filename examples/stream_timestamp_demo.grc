options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: tag_timestamp_demo
    output_language: python
    title: Tag Timestamp demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: latency_stream_time_stamper_0
  id: latency_stream_time_stamper
  parameters:
    key_string: '"time"'
    packet_len: '2048'
    type: float
    vlen: '1'
  states: {}
- name: latency_tag_timestamp_debug_0_0
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: streamdemo
    num_inputs: '1'
    type: float
    vlen: '1'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', latency_stream_time_stamper_0, '0']
- [latency_stream_time_stamper_0, '0', blocks_tag_debug_0, '0']
- [latency_stream_time_stamper_0, '0', latency_tag_timestamp_debug_0_0, '0']

metadata:
  file_format: 1
